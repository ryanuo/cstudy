# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\RTE;.\RTE\Device\STM32F407ZE;.\USER;.\HARDWARE;.\SYSTEM;.\AGREEMENT;.\WEB;.\FreeRTOS;.\FreeRTOS\src;.\FreeRTOS\inc;.\FreeRTOS\port;.\FreeRTOS\head
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c FreeRTOSConfig.h
  group HARDWARE
    ./HARDWARE/: LED.c LED.h BEEP.c BEEP.h KEY.c KEY.h LIGHTSENSOR.c LIGHTSENSOR.h FAN.c FAN.h EXTI.c EXTI.h TIM.c TIM.h TIM6.c OLED.c OLED.h OLED_Data.c OLED_Data.h CountSensor.h CountSensor.c Encoder.c Encoder.h Timer.c Timer.h ETIM.c ETIM.h ADC.c ADC.h DAC.c DAC.h INOUT.c INOUT.h PWR.h PWR.c esp8266.c esp8266.h DHT11.c DHT11.h
  group SYSTEM
    ./SYSTEM/: DELAY.c DELAY.h
  group AGREEMENT
    ./AGREEMENT/: USART.c USART.h SPI.h SPI.c W25QXX.c W25QXX.h IIC.c IIC.h CAN.c CAN.h AT24C02.c AT24C02.h
  group WEB
    ./WEB/: web.c web.h beep_web.c beep_web.h fan_web.c fan_web.h flash_web.c flash_web.h led_web.c led_web.h sensor_web.c sensor_web.h
  group FreeRTOS/src
    ./FREERTOS/src/: list.c queue.c tasks.c timers.c
  group FreeRTOS/inc
    ./FREERTOS/inc/: atomic.h CMakeLists.txt croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/port
    ./FreeRTOS/port/: port.c portmacro.h
  group FreeRTOS/head
    ./FREERTOS/head/: heap_4.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
