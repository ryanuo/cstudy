# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE;.\RTE\Device\STM32F407ZE;.\USER;.\HARDWARE;.\SYSTEM;.\AGREEMENT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/: LED.c LED.h BEEP.c BEEP.h KEY.c KEY.h LIGHT.c LIGHT.h EXTI.c EXTI.h TIM.c TIM.h PWM.c PWM.h IWDG.c IWDG.h WWDG.c WWDG.h FLASH.c FLASH.h ADC.c ADC.h DAC.c DAC.h PWR.c PWR.h
  group SYSTEM
    ./SYSTEM/: DELAY.c DELAY.h BITBAND.h
  group AGREEMENT
    ./AGREEMENT/: USART.c USART.h ONEWIREBUS.c ONEWIREBUS.h SPI.c SPI.h W25Q128.c W25Q128.h IIC.c IIC.h AT24C02.c AT24C02.h CAN.c CAN.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
